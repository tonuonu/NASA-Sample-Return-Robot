# IAR project SPI-Gyro-shield.ewp, settings and files
configuration Debug (R32C, debug)
  General.OGChipSelectMenu: R5F64112 R5F64112
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0xE0
  General.HeapSize: 0x400
  ICCR32C.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCR32C.IccLang: 0
  AR32C.AsmStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkR5F64112.xcl
  XLINK.XlinkCStackSize: 1
  XLINK.XlinkIStackSize: 1
  XLINK.XlinkHeapSize: 1
configuration Release (R32C)
  as the first configuration, except:
  General.OGChipSelectMenu: r32c Generic R32C
  ICCR32C.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: hwsetup.c interrupt.c main.c SPI0.c SPI2.c SPI3.c SPI4.c SPI5.c
