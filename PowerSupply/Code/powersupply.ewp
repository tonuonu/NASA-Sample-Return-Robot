# IAR project powersupply.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F5630A R5F5630A
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: USBStack\; USBStack\CDC\; ..\
  ICCRX.IccExtraOptions: --diag_suppress Pa082
  ICCRX.IccLang: 2
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: powersupply.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: powersupply.hex
  group (top)
    ./: adc12repeat.cpp hwsetup.cpp interrupt-main.cpp led.c log.c low_voltage_detection.cpp main.cpp oled.cpp pwm.cpp rtc.cpp shell.c spi.c switch.cpp usb.c
  group USBStack
    USBStack/CDC/: usb_cdc.c usbdescriptors.c
    USBStack/: usb_core.c usb_hal.c
